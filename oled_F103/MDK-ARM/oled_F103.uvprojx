# Keil uVision project oled_F103.uvprojx, settings and files
target oled_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8004000-0x800EFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: oled_F103 +hex
  AfterMake: "D:\Program Files (x86)\Keil_v5\ARM\ARMCC\bin\fromelf.exe" --bin --output .\oled_F103\oled_F103.bin .\oled_F103\oled_F103.axf
  AfterMake: python ..\tools\ota_pack.py --input .\oled_F103\oled_F103.bin --output .\oled_F103\oled_F103.ota.bin --app-addr 0x08004000 --sw-version 1
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,NDEBUG
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../MDK-ARM;../BSP;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xb000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../BSP/: OLED.c OLED_Data.c WS2812B.c esp8266.c core_json.c flash.c ee.c md5.c otadriver.c spi_flash.c ota_storage.c ota_verify.c crc32.c
software components: CMSIS:CORE 6.0.0
